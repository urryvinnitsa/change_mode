# Keil uVision project chang_mode.uvprojx, settings and files
target chang_mode (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: change_mode +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,USE_HSE=25000000,
  c misc: --no_strict --gnu --enum_is_int
  c include: .\src;.\spl_lib\inc;.\spl_lib\src;.\contiki;.\contiki\lib;.\contiki\sys;.\inc;.\mavlink;.\mavlink\common;.\mavlink\minimal
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\411_0600_07ff.sct
  group src
    ./src/: main.c init.c button.c exe.c
  group startup
    ./startup/: system_stm32f4xx.c startup_stm32f411xe.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h stm32f4xx_it.c system_stm32f4xx.h
  group spl_lib
    ./spl_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group contiki
    ./contiki/: contiki.h contiki-conf.h contiki-default-conf.h contiki-lib.h contiki-net.h contiki-version.h nvic.h rtimer-arch.h
    ./contiki/sys/: autostart.c clock.c ctimer.c etimer.c process.c rtimer.c timer.c autostart.h cc.h clock.h ctimer.h etimer.h lc.h lc-switch.h process.h procinit.h profile.h pt.h rtimer.h timer.h timetable.h timetable-aggregate.h
    ./contiki/lib/: list.h memb.h random.h list.c memb.c random.c
  group inc
    ./inc/: init.h main.h button.h hard_config.h exe.h
  group mavlink
    ./mavlink/: checksum.h mavlink_conversions.h mavlink_get_info.h mavlink_helpers.h mavlink_sha256.h mavlink_types.h protocol.h
